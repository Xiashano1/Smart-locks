## esp32/sdkconfig.defaults
```kconfig
# LVGL 颜色配置
CONFIG_LV_COLOR_DEPTH_16=y
# ESP32 配置
CONFIG_ESP32_DEFAULT_CPU_FREQ_240=y
CONFIG_FREERTOS_HZ=1000
```
